# Keil uVision project Stm32F103UsbIrCtl.uvproj, settings and files
target Stm32F103UsbIrCtl (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: UsbIrCtl +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: ..\CMSIS;..\Libraries\inc;..\Headers;..\Devices;..\Drivers;..\Devices\Ir;..\Devices\Usb\inc;..\User;..\Libraries\STM32_USB-FS-Device_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Headers
    ../Headers/: stm32f10x_conf.h stm32f10x_it.h
  group Libraries/src
    ../Libraries/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
  group Startup
    ../Startup/: startup_stm32f10x_md.s
  group User
    ../User/: main.c stm32f10x_it.c
  group Drivers
    ../Drivers/: Delay.c
  group Usb
    ../Devices/Usb/src/: usb_prop.c usb_pwr.c usb_istr.c usb_endp.c usb_desc.c
    ../Libraries/STM32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group Ir
    ../Devices/Ir/: remote.c
